# Keil uVision project VehicleNumberDeal.uvprojx, settings and files
target Vehicle_Number_Deal (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030,USE_STDPERIPH_DRIVER
  c include: .\App;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\STM32F0xx_StdPeriph_Driver\src;.\Bsp;.\App\RS485;.\App\vehicle;.\App\wiegand;.\App\basic;.\App\global_var;.\App\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f051.s
  group STM32F0xx_StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_syscfg.c
  group CMSIS
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f0xx.c
  group App
    ./App/: main.c stm32f0xx_it.c systick.c
    ./App/RS485/: RS485.c
    ./App/vehicle/: vehicle_number.c
    ./App/wiegand/: wiegand.c
    ./App/basic/: basic.c
    ./App/global_var/: global_var.c
    ./App/usart/: usart.c
